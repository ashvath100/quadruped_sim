Commit message: kinematics class

File: quad.urdf (robot description, URDF)
Before this commit: robot materials, 17 links, 16 joints
Links:
- link base_link: mass 20.843 -> 200.843
